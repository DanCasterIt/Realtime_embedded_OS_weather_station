# Keil uVision project OS3-TCPIP-HTTPs-DHCPc-KSDK-No-Source.uvproj, settings and files
target OS3-TCPIP-HTTPs-DHCPc-KSDK-No-Source FLASH (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OS3-TCPIP-HTTPs-DHCPc-KSDK-No-Source
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, KEIL, FSL_RTOS_UCOSIII
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../;../../BSP;../../BSP/KSDK;../../../../../Software/uC-Common;../../../../../Software/uC-DHCPc;../../../../../Software/uC-HTTPs;../../../../../Software/uC-TCPIP;../../../KSDK/rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView;../../../KSDK/rtos/uCOSIII/src/uCOS-III;../../../KSDK/rtos/uCOSIII/src/uCOS-III/Source;../../../KSDK/rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/RealView;../../../KSDK/rtos/uCOSIII/src/uC-CPU;../../../KSDK/rtos/uCOSIII/src/uC-LIB;../../../KSDK/platform/utilities;../../../KSDK/platform/osa;../../../KSDK/platform/CMSIS/Include;../../../KSDK/platform/CMSIS/Include/device;../../../KSDK/platform/CMSIS/Include/device/MK64F12;../../../KSDK/platform/startup/MK64F12;../../../KSDK/platform/hal;../../../KSDK/platform/hal/adc;../../../KSDK/platform/hal/can;../../../KSDK/platform/hal/dac;../../../KSDK/platform/hal/dmamux;../../../KSDK/platform/hal/dspi;../../../KSDK/platform/hal/edma;../../../KSDK/platform/hal/enet;../../../KSDK/platform/hal/flextimer;../../../KSDK/platform/hal/gpio;../../../KSDK/platform/hal/i2c;../../../KSDK/platform/hal/lptmr;../../../KSDK/platform/hal/mcg;../../../KSDK/platform/hal/osc;../../../KSDK/platform/hal/pdb;../../../KSDK/platform/hal/pit;../../../KSDK/platform/hal/pmc;../../../KSDK/platform/hal/port;../../../KSDK/platform/hal/rtc;../../../KSDK/platform/hal/sai;../../../KSDK/platform/hal/sdhc;../../../KSDK/platform/hal/sim;../../../KSDK/platform/hal/smc;../../../KSDK/platform/hal/spi;../../../KSDK/platform/hal/uart;../../../KSDK/platform/hal/wdog;../../../KSDK/platform/drivers;../../../KSDK/platform/drivers/adc;../../../KSDK/platform/drivers/adc/common;../../../KSDK/platform/drivers/can;../../../KSDK/platform/drivers/can/common;../../../KSDK/platform/drivers/edma;../../../KSDK/platform/drivers/edma/common;../../../KSDK/platform/drivers/dac;../../../KSDK/platform/drivers/dac/common;../../../KSDK/platform/drivers/dspi/dspi_master;../../../KSDK/platform/drivers/dspi/dspi_slave;../../../KSDK/platform/drivers/dspi/common;../../../KSDK/platform/drivers/enet;../../../KSDK/platform/drivers/enet/common;../../../KSDK/platform/drivers/enet/src;../../../KSDK/platform/drivers/flash;../../../KSDK/platform/drivers/flextimer;../../../KSDK/platform/drivers/flextimer/common;../../../KSDK/platform/drivers/gpio;../../../KSDK/platform/drivers/gpio/common;../../../KSDK/platform/drivers/i2c/i2c_master;../../../KSDK/platform/drivers/i2c/i2c_slave;../../../KSDK/platform/drivers/i2c/common;../../../KSDK/platform/drivers/lptmr;../../../KSDK/platform/drivers/lptmr/common;../../../KSDK/platform/drivers/mmcau;../../../KSDK/platform/drivers/pdb;../../../KSDK/platform/drivers/pdb/common;../../../KSDK/platform/drivers/pit;../../../KSDK/platform/drivers/pit/common;../../../KSDK/platform/drivers/rtc;../../../KSDK/platform/drivers/rtc/common;../../../KSDK/platform/drivers/sai;../../../KSDK/platform/drivers/sai/common;../../../KSDK/platform/drivers/sdhc;../../../KSDK/platform/drivers/sdhc/common;../../../KSDK/platform/drivers/sdcard;../../../KSDK/platform/drivers/soundcard;../../../KSDK/platform/drivers/spi;../../../KSDK/platform/drivers/spi/common;../../../KSDK/platform/drivers/uart;../../../KSDK/platform/drivers/uart/common;../../../KSDK/platform/drivers/wdog;../../../KSDK/platform/drivers/wdog/common;../../../KSDK/platform/system/clock;../../../KSDK/platform/system/hwtimer;../../../KSDK/platform/system/interrupt;../../../KSDK/platform/system/power;../../../KSDK/boards/frdmk64f120m
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../BSP/KSDK/KeilMDK/K64FN1Mxxx12_flash.scf
  link misc: OS3-TCPIP-HTTPs-DHCPc-KSDK-Library.lib 
--remove
  group APP
    ../: app.c app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h app_dhcp-c.c app_dhcp-c.h app_http-s.c app_http-s.h app_tcpip.c app_tcpip.h dhcp-c_cfg.h http-s_cfg.h http-s_fs_static_cfg.h http-s_instance_cfg.c http-s_instance_cfg.h net_cfg.c net_cfg.h net_dev_cfg.c net_dev_cfg.h webpages_static.h
  group BSP
    ../../BSP/: bsp_ser.c bsp_ser.h cpu_bsp.c net_bsp.c net_bsp.h
    ../../BSP/KSDK/: startup.c startup.h
    ../../BSP/KSDK/KeilMDK/: startup_MK64F12.s
  group KSDK/boards/frdmk64f120m
    ../../../KSDK/boards/frdmk64f120m/: board.h gpio_pins.c gpio_pins.h hardware_init.c pin_mux.c pin_mux.h
  group KSDK/platform/startup
    ../../../KSDK/platform/startup/MK64F12/: system_MK64F12.c system_MK64F12.h
  group KSDK/platform/utilities
    ../../../KSDK/platform/utilities/: fsl_debug_console.h fsl_misc_utilities.h
    ../../../KSDK/platform/utilities/src/: fsl_debug_console.c fsl_misc_utilities.c
  group KSDK/platform/osa
    ../../../KSDK/platform/osa/src/: fsl_os_abstraction_ucosiii.c
    ../../../KSDK/platform/osa/: fsl_os_abstraction.h fsl_os_abstraction_ucosiii.h
  group KSDK/platform/CMSIS
    ../../../KSDK/platform/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0plus.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../../../KSDK/platform/CMSIS/Include/device/: fsl_device_registers.h
    ../../../KSDK/platform/CMSIS/Include/device/MK64F12/: fsl_bitaccess.h MK64F12.h MK64F12_adc.h MK64F12_aips.h MK64F12_axbs.h MK64F12_can.h MK64F12_cau.h MK64F12_cmp.h MK64F12_cmt.h MK64F12_crc.h MK64F12_dac.h MK64F12_dma.h MK64F12_dmamux.h MK64F12_enet.h MK64F12_ewm.h MK64F12_fb.h MK64F12_fmc.h MK64F12_ftfe.h MK64F12_ftm.h MK64F12_gpio.h MK64F12_i2c.h MK64F12_i2s.h MK64F12_llwu.h MK64F12_lptmr.h MK64F12_mcg.h MK64F12_mcm.h MK64F12_mpu.h MK64F12_nv.h MK64F12_osc.h MK64F12_pdb.h MK64F12_pit.h MK64F12_pmc.h MK64F12_port.h MK64F12_rcm.h MK64F12_rfsys.h MK64F12_rfvbat.h MK64F12_rng.h MK64F12_rtc.h MK64F12_sdhc.h MK64F12_sim.h MK64F12_smc.h MK64F12_spi.h MK64F12_uart.h MK64F12_usb.h MK64F12_usbdcd.h MK64F12_vref.h MK64F12_wdog.h
  group KSDK/platform/system
    ../../../KSDK/platform/system/clock/: fsl_clock_manager.c fsl_clock_manager.h
    ../../../KSDK/platform/system/clock/MK64F12/: fsl_clock_K64F12.c fsl_clock_K64F12.h
    ../../../KSDK/platform/system/interrupt/: fsl_interrupt_features.h fsl_interrupt_manager.h
    ../../../KSDK/platform/system/interrupt/src/: fsl_interrupt_manager.c
  group KSDK/platform/drivers
    ../../../KSDK/platform/drivers/gpio/: fsl_gpio_driver.h
    ../../../KSDK/platform/drivers/gpio/src/: fsl_gpio_driver.c
    ../../../KSDK/platform/drivers/gpio/common/: fsl_gpio_common.c fsl_gpio_common.h
    ../../../KSDK/platform/hal/gpio/: fsl_gpio_features.h fsl_gpio_hal.c fsl_gpio_hal.h
    ../../../KSDK/platform/hal/mcg/: fsl_mcg_features.h fsl_mcg_hal.c fsl_mcg_hal.h fsl_mcg_hal_modes.c fsl_mcg_hal_modes.h
    ../../../KSDK/platform/hal/port/: fsl_port_features.h fsl_port_hal.c fsl_port_hal.h
    ../../../KSDK/platform/hal/sim/: fsl_sim_features.h fsl_sim_hal.c fsl_sim_hal.h
    ../../../KSDK/platform/hal/sim/MK64F12/: fsl_sim_hal_K64F12.c fsl_sim_hal_K64F12.h
    ../../../KSDK/platform/drivers/uart/: fsl_uart_driver.h
    ../../../KSDK/platform/drivers/uart/src/: fsl_uart_driver.c
    ../../../KSDK/platform/drivers/uart/common/: fsl_uart_common.c fsl_uart_common.h
    ../../../KSDK/platform/hal/uart/: fsl_uart_features.h fsl_uart_hal.c fsl_uart_hal.h
  group uC-CPU
    ../../../KSDK/rtos/uCOSIII/src/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
    ../../../KSDK/rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.s cpu_c.c
  group uC-LIB
    ../../../KSDK/rtos/uCOSIII/src/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../KSDK/rtos/uCOSIII/src/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.s
  group uCOS-III Port
    ../../../KSDK/rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uCOS-III Source
    ../../../KSDK/rtos/uCOSIII/src/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC-Common
    ../../../../../Software/uC-Common/KAL/: kal.h
  group uC-DHCPc
    ../../../../../Software/uC-DHCPc/Source/: dhcp-c.h
  group uC-HTTPs
    ../../../../../Software/uC-HTTPs/Source/: http-s.h http-s_mem.h
    ../../../../../Software/uC-HTTPs/OS/: http-s_os.h
    ../../../../../Software/uC-HTTPs/FS/Static/: http-s_fs_static.h
  group uC-TCPIP
    ../../../../../Software/uC-TCPIP/Source/: net.h net_app.h net_ascii.h net_bsd.h net_buf.h net_cache.h net_cfg_net.h net_conn.h net_ctr.h net_def.h net_err.h net_icmp.h net_ip.h net_mgr.h net_sock.h net_stat.h net_tcp.h net_tmr.h net_type.h net_udp.h net_util.h
    ../../../../../Software/uC-TCPIP/IP/IPv4/: net_arp.h net_icmpv4.h net_igmp.h net_ipv4.h
    ../../../../../Software/uC-TCPIP/IF/: net_if.h net_if_802x.h net_if_ether.h net_if_loopback.h
    ../../../../../Software/uC-TCPIP/FS/: net_fs.h
    ../../../../../Software/uC-TCPIP/Dev/Ether/MACNet/: net_dev_macnet.h
    ../../../../../Software/uC-TCPIP/Dev/Ether/PHY/Generic/: net_phy.h
  group OS3-TCPIP-HTTPs-DHCPc-Library
    ./: OS3-TCPIP-HTTPs-DHCPc-KSDK-Library.lib
