# IAR project OS3-TCPIP-HTTPs-DHCPc-KSDK-No-Source.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MK64FN1M0VMD12; FSL_RTOS_UCOSIII; IAR
  ICCARM.CCIncludePath2: ../; ../../BSP; ../../BSP/KSDK; ../../../../../Software/uC-Common; ../../../../../Software/uC-DHCPc; ../../../../../Software/uC-HTTPs; ../../../../../Software/uC-TCPIP; ../../../KSDK/rtos/uCOSIII/src/uC-CPU; ../../../KSDK/rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/IAR; ../../../KSDK/rtos/uCOSIII/src/uC-LIB; ../../../KSDK/rtos/uCOSIII/src/uCOS-III; ../../../KSDK/rtos/uCOSIII/src/uCOS-III/Source; ../../../KSDK/rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR; ../../../KSDK/platform/utilities; ../../../KSDK/platform/osa; ../../../KSDK/platform/CMSIS/Include; ../../../KSDK/platform/CMSIS/Include/device; ../../../KSDK/platform/CMSIS/Include/device/MK64F12; ../../../KSDK/platform/startup/MK64F12; ../../../KSDK/platform/hal; ../../../KSDK/platform/hal/adc; ../../../KSDK/platform/hal/can; ../../../KSDK/platform/hal/dac; ../../../KSDK/platform/hal/dmamux; ../../../KSDK/platform/hal/dspi; ../../../KSDK/platform/hal/edma; ../../../KSDK/platform/hal/enet; ../../../KSDK/platform/hal/flextimer; ../../../KSDK/platform/hal/gpio; ../../../KSDK/platform/hal/i2c; ../../../KSDK/platform/hal/lptmr; ../../../KSDK/platform/hal/mcg; ../../../KSDK/platform/hal/osc; ../../../KSDK/platform/hal/pdb; ../../../KSDK/platform/hal/pit; ../../../KSDK/platform/hal/pmc; ../../../KSDK/platform/hal/port; ../../../KSDK/platform/hal/rtc; ../../../KSDK/platform/hal/sai; ../../../KSDK/platform/hal/sdhc; ../../../KSDK/platform/hal/sim; ../../../KSDK/platform/hal/smc; ../../../KSDK/platform/hal/spi; ../../../KSDK/platform/hal/uart; ../../../KSDK/platform/hal/wdog; ../../../KSDK/platform/drivers; ../../../KSDK/platform/drivers/adc; ../../../KSDK/platform/drivers/adc/common; ../../../KSDK/platform/drivers/can; ../../../KSDK/platform/drivers/can/common; ../../../KSDK/platform/drivers/edma; ../../../KSDK/platform/drivers/edma/common; ../../../KSDK/platform/drivers/dac; ../../../KSDK/platform/drivers/dac/common; ../../../KSDK/platform/drivers/dspi/dspi_master; ../../../KSDK/platform/drivers/dspi/dspi_slave; ../../../KSDK/platform/drivers/dspi/common; ../../../KSDK/platform/drivers/enet; ../../../KSDK/platform/drivers/enet/common; ../../../KSDK/platform/drivers/enet/src; ../../../KSDK/platform/drivers/flash; ../../../KSDK/platform/drivers/flextimer; ../../../KSDK/platform/drivers/flextimer/common; ../../../KSDK/platform/drivers/gpio; ../../../KSDK/platform/drivers/gpio/common; ../../../KSDK/platform/drivers/i2c/i2c_master; ../../../KSDK/platform/drivers/i2c/i2c_slave; ../../../KSDK/platform/drivers/i2c/common; ../../../KSDK/platform/drivers/lptmr; ../../../KSDK/platform/drivers/lptmr/common; ../../../KSDK/platform/drivers/mmcau; ../../../KSDK/platform/drivers/pdb; ../../../KSDK/platform/drivers/pdb/common; ../../../KSDK/platform/drivers/pit; ../../../KSDK/platform/drivers/pit/common; ../../../KSDK/platform/drivers/rtc; ../../../KSDK/platform/drivers/rtc/common; ../../../KSDK/platform/drivers/sai; ../../../KSDK/platform/drivers/sai/common; ../../../KSDK/platform/drivers/sdhc; ../../../KSDK/platform/drivers/sdhc/common; ../../../KSDK/platform/drivers/sdcard; ../../../KSDK/platform/drivers/soundcard; ../../../KSDK/platform/drivers/spi; ../../../KSDK/platform/drivers/spi/common; ../../../KSDK/platform/drivers/uart; ../../../KSDK/platform/drivers/uart/common; ../../../KSDK/platform/drivers/wdog; ../../../KSDK/platform/drivers/wdog/common; ../../../KSDK/platform/system/clock; ../../../KSDK/platform/system/hwtimer; ../../../KSDK/platform/system/interrupt; ../../../KSDK/platform/system/power; ../../../KSDK/boards/frdmk64f120m
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OS3-KSDK.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../BSP/KSDK/IAR/K64FN1Mxxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: OS3-TCPIP-HTTPs-DHCPc-KSDK-Library.a
  group APP
    ../: app.c app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group APP/DHCPc
    ../: app_dhcp-c.c app_dhcp-c.h dhcp-c_cfg.h
  group APP/HTTPs
    ../: app_http-s.c app_http-s.h http-s_cfg.h http-s_fs_static_cfg.h http-s_instance_cfg.c http-s_instance_cfg.h webpages_static.h
  group APP/TCPIP
    ../: app_tcpip.c app_tcpip.h net_cfg.c net_cfg.h net_dev_cfg.c net_dev_cfg.h
  group BSP
    ../../BSP/: bsp_ser.c bsp_ser.h cpu_bsp.c net_bsp.c net_bsp.h
  group BSP/KSDK
    ../../BSP/KSDK/: startup.c startup.h
  group BSP/KSDK/IAR
    ../../BSP/KSDK/IAR/: K64FN1Mxxx12_flash.icf startup_MK64F12.s
  group KSDK/boards/frdmk64f120m
    ../../../KSDK/boards/frdmk64f120m/: board.h gpio_pins.c gpio_pins.h hardware_init.c pin_mux.c pin_mux.h
  group KSDK/platform/CMSIS/Include
    ../../../KSDK/platform/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0plus.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group KSDK/platform/CMSIS/Include/Device
    ../../../KSDK/platform/CMSIS/Include/device/: fsl_device_registers.h
  group KSDK/platform/CMSIS/Include/Device/MK64F12
    ../../../KSDK/platform/CMSIS/Include/device/MK64F12/: fsl_bitaccess.h MK64F12.h MK64F12_adc.h MK64F12_aips.h MK64F12_axbs.h MK64F12_can.h MK64F12_cau.h MK64F12_cmp.h MK64F12_cmt.h MK64F12_crc.h MK64F12_dac.h MK64F12_dma.h MK64F12_dmamux.h MK64F12_enet.h MK64F12_ewm.h MK64F12_fb.h MK64F12_fmc.h MK64F12_ftfe.h MK64F12_ftm.h MK64F12_gpio.h MK64F12_i2c.h MK64F12_i2s.h MK64F12_llwu.h MK64F12_lptmr.h MK64F12_mcg.h MK64F12_mcm.h MK64F12_mpu.h MK64F12_nv.h MK64F12_osc.h MK64F12_pdb.h MK64F12_pit.h MK64F12_pmc.h MK64F12_port.h MK64F12_rcm.h MK64F12_rfsys.h MK64F12_rfvbat.h MK64F12_rng.h MK64F12_rtc.h MK64F12_sdhc.h MK64F12_sim.h MK64F12_smc.h MK64F12_spi.h MK64F12_uart.h MK64F12_usb.h MK64F12_usbdcd.h MK64F12_vref.h MK64F12_wdog.h
  group KSDK/platform/drivers/gpio
    ../../../KSDK/platform/drivers/gpio/common/: fsl_gpio_common.c fsl_gpio_common.h
    ../../../KSDK/platform/drivers/gpio/src/: fsl_gpio_driver.c
    ../../../KSDK/platform/drivers/gpio/: fsl_gpio_driver.h
    ../../../KSDK/platform/hal/gpio/: fsl_gpio_features.h fsl_gpio_hal.c fsl_gpio_hal.h
  group KSDK/platform/drivers/mcg
    ../../../KSDK/platform/hal/mcg/: fsl_mcg_features.h fsl_mcg_hal.c fsl_mcg_hal.h
  group KSDK/platform/drivers/port
    ../../../KSDK/platform/hal/port/: fsl_port_features.h fsl_port_hal.c fsl_port_hal.h
  group KSDK/platform/drivers/sim
    ../../../KSDK/platform/hal/sim/: fsl_sim_features.h fsl_sim_hal.c fsl_sim_hal.h
    ../../../KSDK/platform/hal/sim/MK64F12/: fsl_sim_hal_K64F12.c fsl_sim_hal_K64F12.h
  group KSDK/platform/drivers/uart
    ../../../KSDK/platform/drivers/uart/common/: fsl_uart_common.c fsl_uart_common.h
    ../../../KSDK/platform/drivers/uart/src/: fsl_uart_driver.c
    ../../../KSDK/platform/drivers/uart/: fsl_uart_driver.h
    ../../../KSDK/platform/hal/uart/: fsl_uart_features.h fsl_uart_hal.c fsl_uart_hal.h
  group KSDK/platform/osa
    ../../../KSDK/platform/osa/: fsl_os_abstraction.h fsl_os_abstraction_ucosii.h
    ../../../KSDK/platform/osa/src/: fsl_os_abstraction_ucosiii.c
  group KSDK/platform/startup/MK64F12
    ../../../KSDK/platform/startup/MK64F12/: system_MK64F12.c system_MK64F12.h
  group KSDK/platform/system/clock
    ../../../KSDK/platform/system/clock/MK64F12/: fsl_clock_K64F12.c fsl_clock_K64F12.h
    ../../../KSDK/platform/system/clock/: fsl_clock_manager.c fsl_clock_manager.h
  group KSDK/platform/system/interrupt
    ../../../KSDK/platform/system/interrupt/: fsl_interrupt_features.h fsl_interrupt_manager.h
    ../../../KSDK/platform/system/interrupt/src/: fsl_interrupt_manager.c
  group KSDK/platform/utilities
    ../../../KSDK/platform/utilities/src/: fsl_debug_console.c fsl_misc_utilities.c
    ../../../KSDK/platform/utilities/: fsl_debug_console.h fsl_misc_utilities.h
  group uC-Common/KAL
    ../../../../../Software/uC-Common/KAL/: kal.h
  group uC-CPU
    ../../../KSDK/rtos/uCOSIII/src/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group uC-CPU/ARM-Cortex-M4/IAR
    ../../../KSDK/rtos/uCOSIII/src/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC-DHCPc/Source
    ../../../../../Software/uC-DHCPc/Source/: dhcp-c.h
  group uC-HTTPs/FS/Static
    ../../../../../Software/uC-HTTPs/FS/Static/: http-s_fs_static.h
  group uC-HTTPs/OS
    ../../../../../Software/uC-HTTPs/OS/: http-s_os.h
  group uC-HTTPs/Source
    ../../../../../Software/uC-HTTPs/Source/: http-s.h http-s_mem.h
  group uC-LIB
    ../../../KSDK/rtos/uCOSIII/src/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC-LIB/Ports/ARM-Cortex-M4/IAR
    ../../../KSDK/rtos/uCOSIII/src/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC-TCPIP/Dev/Ether/MACNet
    ../../../../../Software/uC-TCPIP/Dev/Ether/MACNet/: net_dev_macnet.h
  group uC-TCPIP/Dev/Ether/PHY/Generic
    ../../../../../Software/uC-TCPIP/Dev/Ether/PHY/Generic/: net_phy.h
  group uC-TCPIP/FS
    ../../../../../Software/uC-TCPIP/FS/: net_fs.h
  group uC-TCPIP/IF
    ../../../../../Software/uC-TCPIP/IF/: net_if.h net_if_802x.h net_if_ether.h net_if_loopback.h
  group uC-TCPIP/IP/IPv4
    ../../../../../Software/uC-TCPIP/IP/IPv4/: net_arp.h net_icmpv4.h net_igmp.h net_ipv4.h
  group uC-TCPIP/Source
    ../../../../../Software/uC-TCPIP/Source/: net.h net_app.h net_ascii.h net_bsd.h net_buf.h net_cache.h net_cfg_net.h net_conn.h net_ctr.h net_def.h net_err.h net_icmp.h net_ip.h net_mgr.h net_sock.h net_stat.h net_tcp.h net_tmr.h net_type.h net_udp.h net_util.h
  group uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR
    ../../../KSDK/rtos/uCOSIII/src/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOS-III/Source
    ../../../KSDK/rtos/uCOSIII/src/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
